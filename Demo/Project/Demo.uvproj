# Keil uVision project Demo.uvproj, settings and files
target Signal Aquiring (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Demo +hex
  c flags: Optim=1
  c include: ..\..\common\inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../common/startup/: stm32f10x_vector.s
  group Common Files
    ../../common/src/: lcd.c spi_flash.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_usart.c cortexm3_macro.s
  group App
    ../Src/: app_usart.c Main.c stm32f10x_it.c ads1256.c stim_process.c
